# Keil uVision project W11_CapstoneProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: W11_CapstoneProject +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Base_Lib.h LCD16x2.h main.c main.h IR_Reading.h ThreeWiresProtocol.h
