# Keil uVision project W9.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: W9 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Base_Lib.h DS1302.h IR_Reading.h LED7Seg_OnKit.h ThreeWiresProtocol.h main.c main.h
