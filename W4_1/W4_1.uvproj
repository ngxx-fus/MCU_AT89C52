# Keil uVision project W4_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: W4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1307.h LCD16x2.h LCD16X2_CMDs.h LCD16x2_DATE_TIME.h main.c
