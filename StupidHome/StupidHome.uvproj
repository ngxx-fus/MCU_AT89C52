# Keil uVision project StupidHome.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: StupidHome +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1302.h IR_Reading.h LCD_1602.h main.c main.h String_Ultils.h ThreeWiresProtocol.h Time.h UART_BLE.h Utilities.h XPT2046.h
