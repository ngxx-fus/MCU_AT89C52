# Keil uVision project LVN.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LVN +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: base_lib.h DS1302.h LED.h main.c main.h ThreeWiresProtocol.h
